# Keil uVision project ee14lab1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ee14lab1 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    C:/Users/tlyons01/Downloads/STM32L4_Lab_Template_Assembly/STM32L4_Lab_Template_Assembly/: core_cm4_constants.s main.s startup_stm32l476xx.s stm32l476xx_constants.s
    ./: example.s tempConv.s floatConv.s
software components: CMSIS:CORE 5.6.0
